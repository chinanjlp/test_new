# IAR project HA RM_WM_M374.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM374FWUG Toshiba TMPM374FWUG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Source Code\Core; Source Code\Common; Source Code\WM; $TOOLKIT_DIR$\CMSIS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HA RM_WM_M374.srec
  ILINK.IlinkOutputFile: HA RM_WM_M374.out
  ILINK.IlinkIcfFile: HA RM_WM_M374.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common
    Source Code/Common/: DAC.c Display_Error.c
  group Core
    Source Code/Core/: CortexM3_SYS.h ipdefine.h sys_macro.h system_int.c system_int.h tmpm374_sys.c TMPM374_SYS.h vector.c
  group WM
    Source Code/WM/: AllHeaderFiles1.h AllHeaderFiles2.h Com_app.c Com_app.h Customer_app.c D_Driver.c D_Driver.h D_MotorStop.c D_MotorStop.h D_Para.h initial.c initial.h interrupt.c interrupt.h M_Driver.h M_Driver_20170704.a main.c main.h port_def.h SignalCheck.c SignalCheck.h WM.c WM.h
