<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HA RM_WM_M374.ewp</path>
  </project>
  <batchBuild/>
</workspace>


